# Keil uVision project PSoC_pram_controller_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: PSoC_pram_controller_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h Signal_in.c Signal_in.h Signal_in_aliases.h DAC_out.c DAC_out.h DAC_out_aliases.h Clock_1.c Clock_1.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h ADC_DelSig_1.c ADC_DelSig_1.h ADC_DelSig_1_PM.c ADC_DelSig_1_INT.c DMA_1_dma.c DMA_1_dma.h VDAC8_1.c VDAC8_1.h VDAC8_1_PM.c ADC_DelSig_1_theACLK.c ADC_DelSig_1_theACLK.h ADC_DelSig_1_Ext_CP_Clk.c ADC_DelSig_1_Ext_CP_Clk.h Filter_1.c Filter_1.h Filter_1_PM.c Filter_1_PVT.c Filter_1_PVT.h Filter_1_RAM_Data.c Filter_1_Coefficients.c DMA_2_dma.c DMA_2_dma.h Clock_2.c Clock_2.h Control_Reg_1.c Control_Reg_1.h isr_1.c isr_1.h isr_2.c isr_2.h cydisabledsheets.h Opamp_1.c Opamp_1.h Opamp_1_PM.c V_Ref.c V_Ref.h V_Ref_aliases.h PGA_1.c PGA_1.h PGA_1_PM.c ADC_DelSig_1_IRQ.c ADC_DelSig_1_IRQ.h PWM_1.c PWM_1.h PWM_1_PM.c Mobile_motor.c Mobile_motor.h Mobile_motor_aliases.h Cradle_motor.c Cradle_motor.h Cradle_motor_aliases.h AMux_1.c AMux_1.h Temp_in.c Temp_in.h Temp_in_aliases.h IRQ_Zigbee.c IRQ_Zigbee.h IRQ_Zigbee_aliases.h MISO.c MISO.h MISO_aliases.h nRESET.c nRESET.h nRESET_aliases.h WAKE.c WAKE.h WAKE_aliases.h CS.c CS.h CS_aliases.h SCLK.c SCLK.h SCLK_aliases.h MOSI.c MOSI.h MOSI_aliases.h SPI.c SPI.h SPI_PM.c SPI_INT.c SPI_PVT.h isr_Receive_Data.c isr_Receive_Data.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: PSoC_pram_controller_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
